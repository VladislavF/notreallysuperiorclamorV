options:
  parameters:
    author: vlad
    generate_options: qt_gui
    id: test_af_spec
    output_language: python
    title: AF_spectrum
  states: {}

blocks:
- name: fftn
  id: variable
  parameters:
    value: '768'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alpha1: '1'
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    freqhalf: 'False'
    int_max: '0'
    type: float
    update_time: '0.05'
    wintype: window.WIN_BLACKMAN
  states: {}

connections:
- [audio_source_0, '0', qtgui_freq_sink_x_0, '0']
- [audio_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.5.1-37-ga5a387bf
