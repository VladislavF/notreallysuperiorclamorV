options:
  parameters:
    author: vlad
    generate_options: qt_gui
    id: af_vocoder
    output_language: python
    title: AF_spectrum
  states: {}

blocks:
- name: bpf1_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: samp_rate/fftn
    low_cutoff_freq: '0.1'
    samp_rate: samp_rate
    type: band_pass
    width: samp_rate/fftn
    win: window.WIN_HAMMING
  states: {}
- name: bpf2_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: samp_rate/fftn*2
    low_cutoff_freq: samp_rate/fftn
    samp_rate: samp_rate
    type: band_pass
    width: samp_rate/fftn
    win: window.WIN_HAMMING
  states: {}
- name: fftn
  id: variable
  parameters:
    value: '768'
  states: {}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '1'
    gain: '1.0'
    samp_rate: samp_rate
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: lpf_taps
  id: variable
  parameters:
    value: firdes.low_pass(1,samp_rate,1,20*3,0)
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_abs_xx_0_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_abs_xx_0_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/vlad/Documents/SDR testing/grcon23/paint-mask.raw
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.1'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: '0.1'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: test-paint.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/vlad/Downloads/Ottomatic.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from scipy import signal


      class blk(gr.interp_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fs=44100, nperseg=768,overlap=768//2, window="hann"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.interp_block.__init__(
                  self,
                  name='STFT',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64],
                  interp=2
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fs = fs
              self.nperseg = nperseg
              self.overlap = overlap
              self.window = window
              self.set_output_multiple(nperseg)
              #self.set_min_noutput_items(nperseg*2)
              self.set_history(nperseg//2+1)
              print("COLA:", signal.check_COLA(window, nperseg, overlap))
              print("NOLA:", signal.check_NOLA(window, nperseg, overlap))
              
          #def forecast(self, noutput_items, ninputs):
              #ninput_items_required = [(noutput_items//2)+self.nperseg//2] * ninputs
              #print(ninput_items_required)
              #return ninput_items_required

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              lenin = len(input_items[0][:])
              #lenout = len(output_items[0])
              #required = self.forecast(lenout, 1)[0]
              #print("in", lenin, "out", lenout, "used:", required)
              #input_items[0] = input_items[0][:required]
              _, _, outsig = signal.stft(input_items[0][:], fs=self.fs, window=self.window, nperseg=self.nperseg, noverlap=self.overlap, boundary=None, padded=False, return_onesided=False)
              #if self.nitems_written(0) == 0:
                  #print(outsig.shape)
                  #print("in", len(input_items[0]), "out", len(output_items[0]))
              output_items[0][:] = np.array(outsig).flatten(order='C')
              #self.consume(0, required)
              return len(output_items[0])
    fs: samp_rate
    nperseg: fftn
    overlap: fftn//2
    window: '''hann'''
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from scipy import signal


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fs=44100, nperseg=768,overlap=768//2, window="hann"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='ISTFT',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
                  #decim=2
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fs = fs
              self.nperseg = nperseg
              self.overlap = overlap
              self.window = window
              self.set_output_multiple(nperseg)
              self.set_history(nperseg+1)
              print("COLA:", signal.check_COLA(window, nperseg, overlap))
              print("NOLA:", signal.check_NOLA(window, nperseg, overlap))
              
          def forecast(self, noutput_items, ninputs):
              # ninputs is the number of input connections
              # setup size of input_items[i] for work call
              # the required number of input items is returned
              #   in a list where each element represents the
              #   number of required items for each input
              ninput_items_required = [(noutput_items*2)+self.nperseg] * ninputs
              #print(ninput_items_required)
              return ninput_items_required

          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              lenin = len(input_items[0][:])
              lenout = len(output_items[0])
              required = self.forecast(lenout, 1)[0]
              #print("in", lenin, "out", lenout, "used:", required)
              input_items[0] = input_items[0][:required]
              _, outsig = signal.istft(input_items[0].reshape((self.nperseg, required//self.nperseg), order='C'), fs=self.fs, window=self.window, nperseg=self.nperseg, noverlap=self.overlap, boundary=None, input_onesided=False)
              #print(outsig.shape)
              #print(outsig)
              self.consume(0, required)
              output_items[0][:] = np.array(outsig[self.nperseg:])
              return lenout
    fs: samp_rate
    nperseg: fftn
    overlap: fftn//2
    window: '''hann'''
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf1_taps
    type: fff
  states: {state: disabled}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf1_taps
    type: fff
  states: {state: disabled}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf2_taps
    type: fff
  states: {state: disabled}
- name: fft_filter_xxx_0_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf1_taps
    type: fff
  states: {state: disabled}
- name: fft_filter_xxx_0_1_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf2_taps
    type: fff
  states: {state: disabled}
- name: fft_filter_xxx_0_2
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf2_taps
    type: fff
  states: {state: disabled}
- name: fft_filter_xxx_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: lpf_taps
    type: fff
  states: {state: disabled}
- name: fft_filter_xxx_1_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: lpf_taps
    type: fff
  states: {state: disabled}
- name: fft_filter_xxx_1_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: lpf_taps
    type: fff
  states: {state: disabled}
- name: fft_filter_xxx_1_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: lpf_taps
    type: fff
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import scipy as sp
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: audio
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: ISTFT
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: STFT
    size: fftn
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: audio
    type: float
    update_time: 1/30
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_float_to_complex_0, '0']
- [analog_noise_source_x_0, '0', fft_filter_xxx_0_1, '0']
- [analog_noise_source_x_0, '0', fft_filter_xxx_0_1_0, '0']
- [blocks_abs_xx_0, '0', fft_filter_xxx_1, '0']
- [blocks_abs_xx_0_0, '0', fft_filter_xxx_1_0, '0']
- [blocks_abs_xx_0_0_0, '0', fft_filter_xxx_1_0_0, '0']
- [blocks_abs_xx_0_1, '0', fft_filter_xxx_1_1, '0']
- [blocks_add_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_xx_0, '0', fft_filter_xxx_0, '0']
- [blocks_add_xx_0, '0', fft_filter_xxx_0_2, '0']
- [blocks_add_xx_1, '0', audio_sink_0, '0']
- [blocks_add_xx_1, '0', blocks_wavfile_sink_0, '0']
- [blocks_add_xx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_1, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_complex_to_real_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_float_to_complex_0, '0', epy_block_0, '0']
- [blocks_multiply_const_xx_1, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_0, '0', fft_filter_xxx_0_0, '0']
- [blocks_multiply_xx_0_0, '0', fft_filter_xxx_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '1', blocks_add_xx_0, '1']
- [epy_block_0, '0', epy_block_0_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_2, '0']
- [epy_block_0_0, '0', blocks_complex_to_float_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_1, '0']
- [fft_filter_xxx_0, '0', blocks_abs_xx_0, '0']
- [fft_filter_xxx_0_0, '0', blocks_add_xx_1, '0']
- [fft_filter_xxx_0_0_0, '0', blocks_add_xx_1, '1']
- [fft_filter_xxx_0_1, '0', blocks_abs_xx_0_0, '0']
- [fft_filter_xxx_0_1_0, '0', blocks_abs_xx_0_0_0, '0']
- [fft_filter_xxx_0_2, '0', blocks_abs_xx_0_1, '0']
- [fft_filter_xxx_1, '0', blocks_multiply_xx_0, '1']
- [fft_filter_xxx_1_0, '0', blocks_multiply_xx_0, '0']
- [fft_filter_xxx_1_0_0, '0', blocks_multiply_xx_0_0, '0']
- [fft_filter_xxx_1_1, '0', blocks_multiply_xx_0_0, '1']

metadata:
  file_format: 1
  grc_version: v3.10.5.1-37-ga5a387bf
