options:
  parameters:
    category: RDS
    generate_options: qt_gui
    id: rds_tx_nrsc5
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: BB_gain
  id: variable_qtgui_range
  parameters:
    label: Baseband Gain (dB)
    start: '-10'
    step: '0.1'
    stop: '10'
    value: bb_gain
  states: {}
- name: a_lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 16e3
    gain: '0.5'
    samp_rate: audio_rate
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: a_lpf_taps_sca
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 5e3
    gain: '0.5'
    samp_rate: audio_rate
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: afrail
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ana_gain
  id: variable_qtgui_range
  parameters:
    label: Analog Gain
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.45'
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: Audio Gain
    start: '0'
    step: '0.001'
    stop: '2'
    value: '.44'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: bb_clip_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 53e3
    gain: '1'
    samp_rate: usrp_rate
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: bbrail
  id: variable
  parameters:
    value: (1-pilot_gain-rds_gain)
  states: {}
- name: bpf_taps_sca
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: 67e3+5e3
    low_cutoff_freq: 67e3
    samp_rate: usrp_rate
    type: band_pass
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: dc_corr
  id: variable_qtgui_range
  parameters:
    label: DC Correction
    start: '-0.1'
    step: '0.00001'
    stop: '0.1'
    value: dc_offset
  states: {}
- name: decim
  id: variable
  parameters:
    value: 2**15
  states: {}
- name: diff_gain
  id: variable_qtgui_range
  parameters:
    label: DIFF Gain
    start: '0'
    step: '0.001'
    stop: '30'
    value: '1.25'
  states: {}
- name: emphasis_clip_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 15e3
    gain: input_gain
    samp_rate: usrp_rate
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: fm_max_dev
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 90.1e6
  states: {}
- name: input_gain
  id: variable
  parameters:
    value: (0.5-rds_gain/2-pilot_gain/2)*1.95
  states: {}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 105e3
    gain: '1.0'
    samp_rate: tx_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: maxpsdbuf
  id: variable
  parameters:
    value: '128'
  states: {}
- name: nrsc_gain
  id: variable_qtgui_range
  parameters:
    label: Digi Gain
    start: '0'
    step: '0.0001'
    stop: '0.1'
    value: '0.0065'
  states: {}
- name: p1rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: p2rate
  id: variable
  parameters:
    value: '6000'
  states: {}
- name: pilot_gain
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: pilot_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: 1/pilot_gain*2
    high_cutoff_freq: '38020'
    low_cutoff_freq: '37980'
    samp_rate: usrp_rate
    type: band_pass
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: rds_gain
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: rds_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: 59e3
    low_cutoff_freq: 55e3
    samp_rate: usrp_rate
    type: band_pass
    width: '300'
    win: window.WIN_BLACKMAN
  states: {}
- name: sum_gain
  id: variable_qtgui_range
  parameters:
    label: SUM Gain
    start: '0'
    step: '0.001'
    stop: '2'
    value: '1'
  states: {}
- name: threads
  id: variable
  parameters:
    value: '1'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: ana_delay
  id: parameter
  parameters:
    label: Analog Delay (sec)
    type: eng_float
    value: '4.5'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: 15e3
    samp_rate: usrp_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_preemph_0_0
  id: analog_fm_preemph
  parameters:
    fh: 15e3
    samp_rate: usrp_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_preemph_0_1
  id: analog_fm_preemph
  parameters:
    fh: 5e3
    samp_rate: usrp_rate
    tau: '75e-6'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: afrail
    lo: '-afrail'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: afrail
    lo: '-afrail'
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: bbrail
    lo: '-bbrail'
  states: {}
- name: analog_rail_ff_1_0
  id: analog_rail_ff
  parameters:
    hi: bbrail
    lo: '-bbrail'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: '2000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: '3000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: '4000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_4
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: '6000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_5
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: '7000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_6
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: audio_rate/(4*8)
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 67e3
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: bb_gain
  id: parameter
  parameters:
    label: Baseband Gain (dB)
    type: eng_float
    value: '-4'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: dc_corr
    minoutbuf: tx_rate*1
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0_0_4
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_1_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: (len(pilot_taps) - 1) // 2
    type: float
  states: {}
- name: blocks_delay_2_0
  id: blocks_delay
  parameters:
    delay: int(44100*ana_delay)
    type: float
    vlen: '2'
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: tx_500k.raw
    type: complex
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(decim)
    type: float
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '2160'
    n: '4096'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    type: float
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: int(decim)
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_0_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: int(decim)
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: nrsc_gain
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.707'
    type: float
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: ana_gain
    type: complex
  states: {}
- name: blocks_multiply_const_xx_2
  id: blocks_multiply_const_xx
  parameters:
    const: 1/decim
    type: float
  states: {}
- name: blocks_multiply_const_xx_3
  id: blocks_multiply_const_xx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_xx_4
  id: blocks_multiply_const_xx
  parameters:
    const: sum_gain
    type: float
  states: {}
- name: blocks_multiply_const_xx_4_0
  id: blocks_multiply_const_xx
  parameters:
    const: diff_gain
    type: float
  states: {}
- name: blocks_multiply_const_xx_5
  id: blocks_multiply_const_xx
  parameters:
    const: 10**(BB_gain/10)
    type: complex
  states: {}
- name: blocks_multiply_const_xx_6
  id: blocks_multiply_const_xx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_xx_7
  id: blocks_multiply_const_xx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
    vlen: '2048'
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(decim)
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(decim)
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: audio_rate
    type: float
    vlen: '2'
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: audio_rate
    type: float
    vlen: '2'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[math.sin(math.pi / 2 * i / 112) for i in range(112)] + [1] * (2048-112) + [math.cos(math.pi / 2 * i / 112) for i in range(112)]'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_streams_0_0
  id: blocks_vector_to_streams
  parameters:
    type: float
  states: {}
- name: blocks_vector_to_streams_0_1_0
  id: blocks_vector_to_streams
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_vector_to_streams_0_1_0_0
  id: blocks_vector_to_streams
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/vlad/Downloads/Ottomatic.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/vlad/Downloads/Ottomatic.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_1
  id: blocks_wavfile_source
  parameters:
    file: flag9.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1_0
  id: blocks_wavfile_source
  parameters:
    file: flag8_3.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1_0_0
  id: blocks_wavfile_source
  parameters:
    file: flag2.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: flag6.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1_0_0_1
  id: blocks_wavfile_source
  parameters:
    file: flag8_2.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1_0_0_2
  id: blocks_wavfile_source
  parameters:
    file: flag8_4.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1_0_0_3
  id: blocks_wavfile_source
  parameters:
    file: flag8_1.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1_0_0_4
  id: blocks_wavfile_source
  parameters:
    file: /home/vlad/gnuradio3.10/src/gr-nrsc5/apps/sample.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: dc_offset
  id: parameter
  parameters:
    label: BB DC offset
    type: eng_float
    value: '0'
  states: {}
- name: digi_delay
  id: parameter
  parameters:
    label: Digital Delay (sec)
    type: eng_float
    value: '0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    maxoutbuf: '4096'
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: threads
    taps: a_lpf_taps
    type: fff
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: threads
    taps: a_lpf_taps
    type: fff
  states: {}
- name: fft_filter_xxx_0_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: threads
    taps: a_lpf_taps_sca
    type: fff
  states: {}
- name: fft_filter_xxx_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf_taps_sca
    type: fff
  states: {}
- name: fft_filter_xxx_2
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: threads
    taps: pilot_taps
    type: fff
  states: {}
- name: fft_filter_xxx_3
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: threads
    taps: emphasis_clip_taps
    type: fff
  states: {}
- name: fft_filter_xxx_3_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: threads
    taps: emphasis_clip_taps
    type: fff
  states: {}
- name: fft_filter_xxx_4
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: threads
    taps: bb_clip_taps
    type: fff
  states: {}
- name: fft_filter_xxx_5
  id: fft_filter_xxx
  parameters:
    decim: '1'
    nthreads: threads
    taps: lpf_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_6
  id: fft_filter_xxx
  parameters:
    decim: '1'
    maxoutbuf: len(rds_taps)*4
    taps: rds_taps
    type: fff
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(2048)
  states: {}
- name: gr_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: gr_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: gr_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    maxoutbuf: '4096'
    modulus: '2'
  states: {}
- name: gr_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*fm_max_dev/usrp_rate
  states: {}
- name: gr_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[1,2]'
    maxoutbuf: '4096'
  states: {}
- name: gr_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    maxoutbuf: '4096'
    type: float
  states: {}
- name: gr_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: gr_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: rds_gain
    freq: 57e3
    offset: '0'
    phase: '0'
    samp_rate: 380e3
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: pilot_gain
    freq: 19e3
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: gr_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: gr_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    gain: '1'
    interp: '1'
    samp_rate: audio_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 744187.5/tx_rate
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: audio_rate/usrp_rate
    type: float
  states: {}
- name: mmse_resampler_xx_0_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: audio_rate/usrp_rate
    type: float
  states: {}
- name: mmse_resampler_xx_0_0_1
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: usrp_rate/tx_rate
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0_2
  id: mmse_resampler_xx
  parameters:
    maxoutbuf: '4096'
    phase_shift: '0'
    resamp_ratio: 380e3/usrp_rate
    type: float
  states: {}
- name: mmse_resampler_xx_0_0_3
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: audio_rate/usrp_rate
    type: float
  states: {}
- name: mmse_resampler_xx_1
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '1.5'
    type: float
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_1
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '52002'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_1_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52003'
    type: TCP_SERVER
  states: {state: disabled}
- name: network_socket_pdu_0_1_0_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52004'
    type: TCP_SERVER
  states: {state: disabled}
- name: network_socket_pdu_0_1_0_0_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '52004'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_1_1
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '52003'
    type: TCP_SERVER
  states: {}
- name: nrsc5_hdc_encoder_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: p1rate
    channels: '1'
  states: {}
- name: nrsc5_hdc_encoder_0_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: p1rate
    channels: '1'
  states: {}
- name: nrsc5_hdc_encoder_0_0_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: p2rate
    channels: '1'
  states: {}
- name: nrsc5_hdc_encoder_0_0_1
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: p2rate
    channels: '1'
  states: {}
- name: nrsc5_hdc_encoder_0_1
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: p1rate
    channels: '1'
  states: {}
- name: nrsc5_hdc_encoder_0_1_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: p1rate
    channels: '1'
  states: {}
- name: nrsc5_hdc_encoder_0_1_0_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: p1rate
    channels: '1'
  states: {}
- name: nrsc5_hdc_encoder_0_1_0_0_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: p2rate
    channels: '1'
  states: {}
- name: nrsc5_l1_fm_encoder_mp3_0
  id: nrsc5_l1_fm_encoder_mp3
  parameters: {}
  states: {}
- name: nrsc5_l2_encoder_0
  id: nrsc5_l2_encoder
  parameters:
    data_bytes: '1000'
    first_prog: '0'
    maxoutbuf: maxpsdbuf
    num_progs: '6'
    size: '146176'
  states: {}
- name: nrsc5_l2_encoder_0_0
  id: nrsc5_l2_encoder
  parameters:
    data_bytes: '10'
    first_prog: '6'
    maxoutbuf: maxpsdbuf
    num_progs: '2'
    size: '4608'
  states: {}
- name: nrsc5_lot_encoder_0
  id: nrsc5_lot_encoder
  parameters:
    filename: HD1.jpg
    lot_id: '0'
    port: '0x1001'
  states: {}
- name: nrsc5_lot_encoder_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: HD7.png
    lot_id: '6'
    port: '0x100D'
  states: {}
- name: nrsc5_lot_encoder_0_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: '''/home/vlad/Documents/SDR testing/grcon23/HD8a.png'''
    lot_id: '69'
    port: '0x100E'
  states: {state: disabled}
- name: nrsc5_lot_encoder_0_0_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: HD8a.png
    lot_id: '7'
    port: '0x100F'
  states: {}
- name: nrsc5_lot_encoder_0_1
  id: nrsc5_lot_encoder
  parameters:
    filename: /home/vlad/Documents/SLVLAD$$010000.jpg
    lot_id: '42'
    port: '0x1000'
  states: {state: disabled}
- name: nrsc5_lot_encoder_0_2
  id: nrsc5_lot_encoder
  parameters:
    filename: bnm.png
    lot_id: '1'
    port: '0x1003'
  states: {}
- name: nrsc5_lot_encoder_0_2_0
  id: nrsc5_lot_encoder
  parameters:
    filename: dfg.png
    lot_id: '2'
    port: '0x1005'
  states: {}
- name: nrsc5_lot_encoder_0_2_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: zxc.png
    lot_id: '3'
    port: '0x1007'
  states: {}
- name: nrsc5_lot_encoder_0_2_0_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: uio.png
    lot_id: '4'
    port: '0x1009'
  states: {}
- name: nrsc5_lot_encoder_0_3
  id: nrsc5_lot_encoder
  parameters:
    filename: HD6_1.png
    lot_id: '5'
    port: '0x100B'
  states: {}
- name: nrsc5_psd_encoder_0
  id: nrsc5_psd_encoder
  parameters:
    artist: VladFM
    bytes_per_frame: '128'
    maxoutbuf: maxpsdbuf
    prog_num: '0'
    title: Various
  states: {}
- name: nrsc5_psd_encoder_0_0
  id: nrsc5_psd_encoder
  parameters:
    artist: 4A63C7DEA2667B3222CDD6A1746702
    bytes_per_frame: '128'
    maxoutbuf: maxpsdbuf
    prog_num: '5'
    title: 7F4DA1B2C30100
  states: {}
- name: nrsc5_psd_encoder_0_0_0
  id: nrsc5_psd_encoder
  parameters:
    artist: '69'
    bytes_per_frame: '0'
    maxoutbuf: maxpsdbuf
    prog_num: '6'
    title: N
  states: {}
- name: nrsc5_psd_encoder_0_0_0_0
  id: nrsc5_psd_encoder
  parameters:
    artist: '7.'
    bytes_per_frame: '0'
    maxoutbuf: maxpsdbuf
    prog_num: '7'
    title: flag{Nyquist}
  states: {}
- name: nrsc5_psd_encoder_0_1
  id: nrsc5_psd_encoder
  parameters:
    artist: 4.fl
    bytes_per_frame: '128'
    maxoutbuf: maxpsdbuf
    prog_num: '1'
    title: One
  states: {}
- name: nrsc5_psd_encoder_0_1_0
  id: nrsc5_psd_encoder
  parameters:
    artist: ag{watch?v
    bytes_per_frame: '128'
    maxoutbuf: maxpsdbuf
    prog_num: '2'
    title: Two
  states: {}
- name: nrsc5_psd_encoder_0_1_1
  id: nrsc5_psd_encoder
  parameters:
    artist: =uxVhova
    bytes_per_frame: '128'
    maxoutbuf: maxpsdbuf
    prog_num: '3'
    title: Three
  states: {}
- name: nrsc5_psd_encoder_0_1_1_0
  id: nrsc5_psd_encoder
  parameters:
    artist: DK1Q}
    bytes_per_frame: '128'
    maxoutbuf: maxpsdbuf
    prog_num: '4'
    title: Four
  states: {}
- name: nrsc5_sis_encoder_0
  id: nrsc5_sis_encoder
  parameters:
    altitude: '2000'
    country_code: US
    fcc_facility_id: '4213'
    latitude: '47'
    longitude: '-105'
    message: 3. flag{GodsOfTheCopybookHeadings}
    mode: nrsc5.pids_mode.FM
    num_programs: '8'
    program0: nrsc5.program_type.CLASSICAL
    program1: nrsc5.program_type.TALK
    program2: nrsc5.program_type.NEWS
    program3: nrsc5.program_type.NEWS
    program4: nrsc5.program_type.NEWS
    program5: nrsc5.program_type.NEWS
    program6: nrsc5.program_type.NEWS
    program7: nrsc5.program_type.NEWS
    short_name: GRCN
    slogan: 'AES:kjhASty34e987o76w6ta&B6g '
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '14'
    if_gain0: '40'
    sample_rate: tx_rate
    sync: sync
    type: fc32
  states: {}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '0'
    bt709_map: '1'
    image_file: flag16.png
    image_flip: '0'
    image_invert: '0'
    repeatmode: '1'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '1'
    width: '288'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: usrp_rate
    fc: '0'
    fftsize: '16384'
    freqhalf: 'False'
    name: '"TX BB"'
    showports: 'True'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    factor1: fm_max_dev
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Max Deviation
    max: fm_max_dev*1.1
    min: '0'
    type: float
    unit1: kHz
    update_time: 1/30
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: PAPR
    label2: Max Power
    label3: Avg. Power
    max: '40'
    min: '0'
    name: '"Power"'
    nconnections: '3'
    type: float
    unit1: dB
    unit2: dB
    unit3: dB
    update_time: 1/10
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: tx_rate
    fc: freq
    fftsize: '1024'
    rate: 1/10
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: SUM
    label2: DIFF
    name: '"Audio"'
    nconnections: '2'
    size: '1024'
    srate: usrp_rate
    type: float
    update_time: 1/10
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"baseband"'
    size: '1024'
    srate: usrp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: usrp_rate
    fc: '0'
    fftsize: '32768'
    freqhalf: 'False'
    int_max: '0'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '16'
    taps: ''
    type: ccc
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: freq
    maxoutbuf: maxpsdbuf
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '0'
    pi_reference_number: '147'
    ps: GRCon-FM
    pty: '15'
    pty_locale: '1'
    radiotext: 1. flag{AbolitionOfMan}
    ta: 'False'
    tp: 'False'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '160'
    gain: '111'
    interp: '160'
    maxoutbuf: '4096'
    ntaps: 160*11
    samp_rate: 380e3
    sym_rate: '2375'
    type: interp_fir_filter_fff
  states: {}
- name: tx_rate
  id: parameter
  parameters:
    label: TX Rate (Hz)
    type: intx
    value: '2000000'
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://localhost:2000
    timeout: '3000'
    type: float
    vlen: '2'
  states: {}
- name: zeromq_sub_source_0_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://localhost:2000
    timeout: '3000'
    type: float
    vlen: '2'
  states: {}

connections:
- [analog_fm_preemph_0, '0', gr_add_xx_0, '1']
- [analog_fm_preemph_0, '0', gr_sub_xx_0, '1']
- [analog_fm_preemph_0_0, '0', gr_add_xx_0, '0']
- [analog_fm_preemph_0_0, '0', gr_sub_xx_0, '0']
- [analog_fm_preemph_0_1, '0', blocks_multiply_xx_1, '0']
- [analog_rail_ff_0, '0', fft_filter_xxx_3_0, '0']
- [analog_rail_ff_0_0, '0', fft_filter_xxx_3, '0']
- [analog_rail_ff_1, '0', fft_filter_xxx_4, '0']
- [analog_rail_ff_1_0, '0', gr_add_xx_1, '2']
- [analog_sig_source_x_0, '0', nrsc5_hdc_encoder_0_1, '0']
- [analog_sig_source_x_0_0, '0', nrsc5_hdc_encoder_0_1_0, '0']
- [analog_sig_source_x_0_1, '0', nrsc5_hdc_encoder_0_1_0_0, '0']
- [analog_sig_source_x_0_2, '0', nrsc5_hdc_encoder_0_1_0_0_0, '0']
- [analog_sig_source_x_0_4, '0', nrsc5_hdc_encoder_0_0_0, '0']
- [analog_sig_source_x_0_5, '0', nrsc5_hdc_encoder_0_0_1, '0']
- [analog_sig_source_x_0_6, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [blocks_abs_xx_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_abs_xx_1, '0', fft_filter_xxx_2, '0']
- [blocks_add_const_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_add_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_add_xx_0, '0', analog_rail_ff_1, '0']
- [blocks_add_xx_0_0, '0', blocks_multiply_const_xx_5, '0']
- [blocks_add_xx_1_0_0, '0', blocks_multiply_const_xx_6, '0']
- [blocks_add_xx_1_0_0_4, '0', nrsc5_hdc_encoder_0_0, '0']
- [blocks_add_xx_1_0_1, '0', blocks_multiply_const_xx_3, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_complex_to_real_0, '0', mmse_resampler_xx_1, '0']
- [blocks_conjugate_cc_0, '0', mmse_resampler_xx_0, '0']
- [blocks_delay_0, '0', gr_add_xx_1, '1']
- [blocks_delay_2_0, '0', blocks_vector_to_streams_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_2, '0']
- [blocks_keep_m_in_n_0, '0', blocks_multiply_xx_0, '1']
- [blocks_keep_one_in_n_0, '0', blocks_multiply_const_xx_7, '0']
- [blocks_max_xx_0_0, '0', qtgui_number_sink_0, '0']
- [blocks_max_xx_0_0_0, '0', blocks_divide_xx_0, '0']
- [blocks_max_xx_0_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_const_xx_0, '0', analog_fm_preemph_0, '0']
- [blocks_multiply_const_xx_0_0, '0', analog_fm_preemph_0_0, '0']
- [blocks_multiply_const_xx_0_0_0, '0', analog_fm_preemph_0_1, '0']
- [blocks_multiply_const_xx_1, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_xx_2, '0', blocks_divide_xx_0, '1']
- [blocks_multiply_const_xx_2, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_multiply_const_xx_3, '0', nrsc5_hdc_encoder_0, '0']
- [blocks_multiply_const_xx_4, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_xx_4, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_xx_4_0, '0', gr_multiply_xx_1, '1']
- [blocks_multiply_const_xx_4_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_xx_5, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_xx_6, '0', nrsc5_hdc_encoder_0_0_1, '0']
- [blocks_multiply_const_xx_7, '0', nrsc5_hdc_encoder_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_1, '0', fft_filter_xxx_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink_0_0, '1']
- [blocks_nlog10_ff_0_1, '0', qtgui_number_sink_0_0, '2']
- [blocks_repeat_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_max_xx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_max_xx_0_0_0, '0']
- [blocks_throttle2_0, '0', blocks_vector_to_streams_0_1_0_0, '0']
- [blocks_throttle2_0_0, '0', blocks_delay_2_0, '0']
- [blocks_throttle2_0_0, '0', blocks_vector_to_streams_0_1_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_vector_to_streams_0_0, '0', fft_filter_xxx_0, '0']
- [blocks_vector_to_streams_0_0, '1', fft_filter_xxx_0_0, '0']
- [blocks_vector_to_streams_0_1_0, '0', blocks_add_xx_1_0_1, '0']
- [blocks_vector_to_streams_0_1_0, '1', blocks_add_xx_1_0_1, '1']
- [blocks_vector_to_streams_0_1_0_0, '0', blocks_add_xx_1_0_1, '0']
- [blocks_vector_to_streams_0_1_0_0, '1', blocks_add_xx_1_0_1, '1']
- [blocks_wavfile_source_0_0, '0', blocks_add_xx_1_0_1, '0']
- [blocks_wavfile_source_0_0, '1', blocks_add_xx_1_0_1, '1']
- [blocks_wavfile_source_0_1, '0', fft_filter_xxx_0_1, '0']
- [blocks_wavfile_source_0_1_0, '0', nrsc5_hdc_encoder_0_1, '0']
- [blocks_wavfile_source_0_1_0_0, '0', blocks_add_xx_1_0_0, '0']
- [blocks_wavfile_source_0_1_0_0, '1', blocks_add_xx_1_0_0, '1']
- [blocks_wavfile_source_0_1_0_0_0, '0', nrsc5_hdc_encoder_0_0_0, '0']
- [blocks_wavfile_source_0_1_0_0_1, '0', nrsc5_hdc_encoder_0_1_0, '0']
- [blocks_wavfile_source_0_1_0_0_2, '0', nrsc5_hdc_encoder_0_1_0_0, '0']
- [blocks_wavfile_source_0_1_0_0_3, '0', nrsc5_hdc_encoder_0_1_0_0_0, '0']
- [blocks_wavfile_source_0_1_0_0_4, '0', blocks_add_xx_1_0_0_4, '0']
- [blocks_wavfile_source_0_1_0_0_4, '1', blocks_add_xx_1_0_0_4, '1']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [fft_filter_xxx_0, '0', mmse_resampler_xx_0_0, '0']
- [fft_filter_xxx_0_0, '0', mmse_resampler_xx_0_0_0, '0']
- [fft_filter_xxx_0_1, '0', mmse_resampler_xx_0_0_3, '0']
- [fft_filter_xxx_1, '0', gr_add_xx_1, '3']
- [fft_filter_xxx_2, '0', gr_multiply_xx_1, '0']
- [fft_filter_xxx_3, '0', blocks_multiply_const_xx_4, '0']
- [fft_filter_xxx_3_0, '0', blocks_multiply_const_xx_4_0, '0']
- [fft_filter_xxx_4, '0', analog_rail_ff_1_0, '0']
- [fft_filter_xxx_5, '0', blocks_multiply_const_xx_1, '0']
- [fft_filter_xxx_6, '0', gr_add_xx_1, '0']
- [fft_vxx_0, '0', blocks_repeat_0, '0']
- [gr_add_xx_0, '0', analog_rail_ff_0_0, '0']
- [gr_add_xx_1, '0', blocks_abs_xx_0, '0']
- [gr_add_xx_1, '0', gr_frequency_modulator_fc_0, '0']
- [gr_add_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [gr_add_xx_1, '0', qtgui_time_sink_x_0_0, '0']
- [gr_add_xx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [gr_diff_encoder_bb_0, '0', gr_map_bb_1, '0']
- [gr_frequency_modulator_fc_0, '0', blocks_file_sink_0, '0']
- [gr_frequency_modulator_fc_0, '0', mmse_resampler_xx_0_0_1, '0']
- [gr_map_bb_1, '0', gr_unpack_k_bits_bb_0, '0']
- [gr_multiply_xx_0, '0', mmse_resampler_xx_0_0_2, '0']
- [gr_multiply_xx_1, '0', blocks_add_xx_0, '0']
- [gr_sig_source_x_0_0, '0', gr_multiply_xx_0, '0']
- [gr_sig_source_x_0_1, '0', blocks_abs_xx_1, '0']
- [gr_sig_source_x_0_1, '0', blocks_delay_0, '0']
- [gr_sub_xx_0, '0', analog_rail_ff_0, '0']
- [gr_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [low_pass_filter_0, '0', blocks_keep_one_in_n_0, '0']
- [mmse_resampler_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [mmse_resampler_xx_0_0, '0', blocks_multiply_const_xx_0_0, '0']
- [mmse_resampler_xx_0_0, '0', blocks_null_sink_0, '0']
- [mmse_resampler_xx_0_0_0, '0', blocks_multiply_const_xx_0, '0']
- [mmse_resampler_xx_0_0_0, '0', blocks_null_sink_0, '1']
- [mmse_resampler_xx_0_0_1, '0', fft_filter_xxx_5, '0']
- [mmse_resampler_xx_0_0_2, '0', fft_filter_xxx_6, '0']
- [mmse_resampler_xx_0_0_3, '0', blocks_multiply_const_xx_0_0_0, '0']
- [mmse_resampler_xx_1, '0', low_pass_filter_0, '0']
- [network_socket_pdu_0, pdus, rds_encoder_0, rds in]
- [network_socket_pdu_0_1, pdus, nrsc5_psd_encoder_0, set_meta]
- [network_socket_pdu_0_1_0, pdus, nrsc5_psd_encoder_0_0, set_meta]
- [network_socket_pdu_0_1_0_0, pdus, nrsc5_lot_encoder_0_1, file]
- [network_socket_pdu_0_1_0_0_0, pdus, nrsc5_lot_encoder_0_0_0, file]
- [network_socket_pdu_0_1_0_0_0, pdus, nrsc5_lot_encoder_0_0_0_0, file]
- [network_socket_pdu_0_1_1, pdus, nrsc5_psd_encoder_0_0_0_0, set_meta]
- [nrsc5_hdc_encoder_0, '0', nrsc5_l2_encoder_0, '0']
- [nrsc5_hdc_encoder_0_0, '0', nrsc5_l2_encoder_0, '5']
- [nrsc5_hdc_encoder_0_0_0, '0', nrsc5_l2_encoder_0_0, '0']
- [nrsc5_hdc_encoder_0_0_1, '0', nrsc5_l2_encoder_0_0, '1']
- [nrsc5_hdc_encoder_0_1, '0', nrsc5_l2_encoder_0, '1']
- [nrsc5_hdc_encoder_0_1_0, '0', nrsc5_l2_encoder_0, '2']
- [nrsc5_hdc_encoder_0_1_0_0, '0', nrsc5_l2_encoder_0, '3']
- [nrsc5_hdc_encoder_0_1_0_0_0, '0', nrsc5_l2_encoder_0, '4']
- [nrsc5_l1_fm_encoder_mp3_0, '0', fft_vxx_0, '0']
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0, clock]
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0_0, clock]
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0_0_0, clock]
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0_0_0_0, clock]
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0_1, clock]
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0_1_0, clock]
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0_1_1, clock]
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0_1_1_0, clock]
- [nrsc5_l2_encoder_0, '0', nrsc5_l1_fm_encoder_mp3_0, '0']
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_0_0_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_1, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_3, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_sis_encoder_0, ready]
- [nrsc5_l2_encoder_0_0, '0', nrsc5_l1_fm_encoder_mp3_0, '1']
- [nrsc5_l2_encoder_0_0, ready, nrsc5_lot_encoder_0_0_0, ready]
- [nrsc5_l2_encoder_0_0, ready, nrsc5_lot_encoder_0_2, ready]
- [nrsc5_l2_encoder_0_0, ready, nrsc5_lot_encoder_0_2_0, ready]
- [nrsc5_l2_encoder_0_0, ready, nrsc5_lot_encoder_0_2_0_0, ready]
- [nrsc5_l2_encoder_0_0, ready, nrsc5_lot_encoder_0_2_0_0_0, ready]
- [nrsc5_lot_encoder_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_0_0, aas, nrsc5_l2_encoder_0_0, aas]
- [nrsc5_lot_encoder_0_0_0_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_1, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_2, aas, nrsc5_l2_encoder_0_0, aas]
- [nrsc5_lot_encoder_0_2_0, aas, nrsc5_l2_encoder_0_0, aas]
- [nrsc5_lot_encoder_0_2_0_0, aas, nrsc5_l2_encoder_0_0, aas]
- [nrsc5_lot_encoder_0_2_0_0_0, aas, nrsc5_l2_encoder_0_0, aas]
- [nrsc5_lot_encoder_0_3, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_psd_encoder_0, '0', nrsc5_l2_encoder_0, '6']
- [nrsc5_psd_encoder_0_0, '0', nrsc5_l2_encoder_0, '11']
- [nrsc5_psd_encoder_0_0_0, '0', nrsc5_l2_encoder_0_0, '2']
- [nrsc5_psd_encoder_0_0_0_0, '0', nrsc5_l2_encoder_0_0, '3']
- [nrsc5_psd_encoder_0_1, '0', nrsc5_l2_encoder_0, '7']
- [nrsc5_psd_encoder_0_1_0, '0', nrsc5_l2_encoder_0, '8']
- [nrsc5_psd_encoder_0_1_1, '0', nrsc5_l2_encoder_0, '9']
- [nrsc5_psd_encoder_0_1_1_0, '0', nrsc5_l2_encoder_0, '10']
- [nrsc5_sis_encoder_0, '0', nrsc5_l1_fm_encoder_mp3_0, '2']
- [nrsc5_sis_encoder_0, aas, nrsc5_l2_encoder_0, aas]
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_paint_bc_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0_0, '1']
- [rds_encoder_0, '0', gr_diff_encoder_bb_0, '0']
- [root_raised_cosine_filter_0, '0', gr_multiply_xx_0, '1']
- [zeromq_sub_source_0_0, '0', blocks_throttle2_0_0, '0']
- [zeromq_sub_source_0_0_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.5.1-37-ga5a387bf
